File: coil_relay.sch (KiCad schematic (older format))
At the start: 20 parts

Commit message: update,
Parts:
- gave numbers to parts that had none: 20
