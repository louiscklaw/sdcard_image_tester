File: sdcard_reader.sch (KiCad schematic (older format))
At the start: 22 parts

Commit message: update,
Parts:
- gave numbers to parts that had none: 22
