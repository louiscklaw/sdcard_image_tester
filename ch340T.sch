File: ch340T.sch (KiCad schematic (older format))
At the start: 10 parts

Commit message: update,
Parts:
- gave numbers to parts that had none: 10
