File: sdcard_switch.sch (KiCad schematic (older format))
At the start: 14 parts

Commit message: update,
Parts:
- gave numbers to parts that had none: 14
